# Keil uVision project Stm32-Robot.uvprojx, settings and files
target Robot (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Stm32-Robot
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F429_439xx, USE_STDPERIPH_DRIVER
  c include: .\Bsp;.\Driver;.\Stm32Libs\CMSIS\CoreSupport;.\Stm32Libs\CMSIS\DeviceSupport\ST\STM32F4xx;.\Stm32Libs\STM32F4xx_StdPeriph_Driver\inc;.\Stm32Libs\STM32F4xx_StdPeriph_Driver;.\RosLibs;.\SYSTEM\usart;.\Driver\bsp_stm32f4xx\inc;.\SYSTEM\sys;.\SYSTEM\delay
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.cpp
  group Library
    ./Stm32Libs/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Driver
    ./Driver/: battery.cpp encoder.cpp gy85.cpp Kinematics.cpp led.cpp motor.cpp PID.cpp JXBS3001GZ.c ks103.c GYMPU680.c IR.c mcu2yt.c mcu2dy.c IR_Recevie.c IR_Send.c fuzzypid.c mcu2ult.c
    ./Driver/bsp_stm32f4xx/src/: bsp_mpu6050.c bsp_i2c_gpio.c
  group Bsp
    ./Bsp/: hardwareserial.cpp interrupt.cpp RingBuffer.cpp Wire.cpp WireBase.cpp millisecondtimer.c
  group Startup
    ./Stm32Libs/CMSIS/DeviceSupport/ST/STM32F4xx/startup/arm/: startup_stm32f429x.s
  group CMSIS
    ./Stm32Libs/CMSIS/DeviceSupport/ST/STM32F4xx/: system_stm32f4xx.c
  group RosLib
    ./RosLibs/: duration.cpp time.cpp
  group System
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
